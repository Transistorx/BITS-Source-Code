#include "log_util.h"

#include <stdio.h>
#include <string.h>

#include "esp_log.h"

void log_change_init(log_change_t *c)
{
    if (c == NULL) return;
    c->last = 0;
    c->seen = false;
}

bool log_on_change(log_change_t *c, int32_t value, int32_t *prev)
{
    if (c == NULL) return false;
    if (c->seen && c->last == value) return false;
    if (prev != NULL) *prev = c->seen ? c->last : LOG_CHANGE_NONE;
    c->last = value;
    c->seen = true;
    return true;
}

void log_ratelimit_init(log_ratelimit_t *r)
{
    if (r == NULL) return;
    r->last_ms = 0U;
    r->pending = 0U;
    r->armed = false;
}

bool log_ratelimit_event(log_ratelimit_t *r, uint32_t now_ms, uint32_t interval_ms,
                         uint32_t *count)
{
    if (r == NULL) return false;
    if (!r->armed) {
        r->armed = true;
        r->last_ms = now_ms;
        r->pending = 0U;
        if (count != NULL) *count = 1U;
        return true;
    }
    if (r->pending < UINT32_MAX) r->pending++;
    /* Unsigned subtraction keeps this correct across the 32-bit ms wrap. */
    if ((uint32_t)(now_ms - r->last_ms) < interval_ms) return false;
    r->last_ms = now_ms;
    if (count != NULL) *count = r->pending;
    r->pending = 0U;
    return true;
}

static size_t finish(int n, size_t cap)
{
    return (n > 0 && (size_t)n < cap) ? (size_t)n : 0U;
}

size_t log_fmt_age_tenths(char *buf, size_t cap, uint32_t age_ms)
{
    if (buf == NULL || cap == 0U) return 0U;
    uint64_t t = ((uint64_t)age_ms + 50U) / 100U;
    return finish(snprintf(buf, cap, "%lu.%lus", (unsigned long)(t / 10U),
                           (unsigned long)(t % 10U)), cap);
}

size_t log_fmt_weight_kg(char *buf, size_t cap, int32_t grams)
{
    if (buf == NULL || cap == 0U) return 0U;
    int64_t g = grams;
    bool neg = g < 0;
    if (neg) g = -g;
    return finish(snprintf(buf, cap, "%s%lu.%03lukg", neg ? "-" : "",
                           (unsigned long)(g / 1000), (unsigned long)(g % 1000)), cap);
}

size_t log_fmt_transition(char *buf, size_t cap, const char *from, const char *to,
                          bool have_age, uint32_t age_ms)
{
    if (buf == NULL || cap == 0U || from == NULL || to == NULL) return 0U;
    if (!have_age) return finish(snprintf(buf, cap, "%s -> %s", from, to), cap);
    char age[24];
    if (log_fmt_age_tenths(age, sizeof(age), age_ms) == 0U) return 0U;
    return finish(snprintf(buf, cap, "%s -> %s age=%s", from, to, age), cap);
}

size_t log_fmt_health(char *buf, size_t cap, const log_health_t *h)
{
    if (buf == NULL || cap == 0U || h == NULL) return 0U;

    char weight[24] = "n/a";
    if (h->weight_valid) (void)log_fmt_weight_kg(weight, sizeof(weight), h->weight_g);

    char age[24] = "n/a";
    if (h->age_valid) {
        uint64_t cs = ((uint64_t)h->age_ms + 5U) / 10U;
        (void)snprintf(age, sizeof(age), "%lu.%02lus", (unsigned long)(cs / 100U),
                       (unsigned long)(cs % 100U));
    }

    return finish(snprintf(buf, cap,
                           "up=%lus heap=%luKB mqtt=%s scale=%s weight=%s rx=%lu "
                           "valid=%lu bad=%lu pub=%lu q=%lu age=%s",
                           (unsigned long)h->uptime_s, (unsigned long)h->heap_kb,
                           h->mqtt_up ? "UP" : "DOWN",
                           h->scale_state != NULL ? h->scale_state : "n/a", weight,
                           (unsigned long)h->rx, (unsigned long)h->valid,
                           (unsigned long)h->bad, (unsigned long)h->pub,
                           (unsigned long)h->queue, age), cap);
}

size_t log_fmt_chan_summary(char *buf, size_t cap, const log_chan_t *c)
{
    if (buf == NULL || cap == 0U || c == NULL) return 0U;

    char last[40] = "last=n/a";
    if (c->has_weight) {
        char kg[24];
        if (log_fmt_weight_kg(kg, sizeof(kg), c->weight_g) == 0U) return 0U;
        (void)snprintf(last, sizeof(last), "last=%s %s", kg, c->stable ? "ST" : "US");
    }
    char age[24] = "n/a";
    if (c->have_age) (void)snprintf(age, sizeof(age), "%lums", (unsigned long)c->age_ms);
    char seq[24] = "n/a";
    if (c->have_seq) (void)snprintf(seq, sizeof(seq), "%lu", (unsigned long)c->cas_seq);

    return finish(snprintf(buf, cap,
                           "RX CH%u/UART%d sel=%s bytes=%lu (%luB/s) frames=%lu valid=%lu(st=%lu us=%lu) "
                           "rej[len=%lu hdr=%lu stat=%lu field=%lu other=%lu term=%lu] "
                           "faults=%lu loopgap=%lums %s age=%s link=%s cas_seq=%s "
                           "fmt=%lu pad=%lu ovl=%lu stall=%lu resync=%lu elf=%lu",
                           (unsigned)c->ch, c->uart, c->selected ? "Y" : "N",
                           (unsigned long)c->bytes, (unsigned long)c->bytes_per_s,
                           (unsigned long)c->frames, (unsigned long)c->valid,
                           (unsigned long)c->valid_st, (unsigned long)c->valid_us,
                           (unsigned long)c->rej_len, (unsigned long)c->rej_hdr,
                           (unsigned long)c->rej_stat, (unsigned long)c->rej_field,
                           (unsigned long)c->rej_other, (unsigned long)c->rej_term,
                           (unsigned long)c->uart_faults, (unsigned long)c->loop_gap_ms, last, age,
                           c->link != NULL ? c->link : "n/a", seq,
                           (unsigned long)c->rej_format, (unsigned long)c->rej_pad,
                           (unsigned long)c->overload, (unsigned long)c->stalls,
                           (unsigned long)c->resyncs, (unsigned long)c->embedded_lf), cap);
}

static size_t hex_ascii(char *buf, size_t cap, const uint8_t *data, size_t len)
{
    /* "hex=AA BB .. ascii=\"..\"" ; the caller guarantees cap is large enough
     * for LOG_RAW_TAIL_MAX bytes, otherwise 0 is returned. */
    size_t n = 0U;
    int w = snprintf(buf, cap, "hex=");
    if (w < 0 || (size_t)w >= cap) return 0U;
    n = (size_t)w;
    for (size_t i = 0U; i < len; i++) {
        w = snprintf(buf + n, cap - n, i == 0U ? "%02X" : " %02X", data[i]);
        if (w < 0 || (size_t)w >= cap - n) return 0U;
        n += (size_t)w;
    }
    w = snprintf(buf + n, cap - n, " ascii=\"");
    if (w < 0 || (size_t)w >= cap - n) return 0U;
    n += (size_t)w;
    if (cap - n < len + 2U) return 0U;
    for (size_t i = 0U; i < len; i++) {
        buf[n++] = (data[i] >= 0x20U && data[i] < 0x7FU && data[i] != '"') ? (char)data[i] : '.';
    }
    buf[n++] = '"';
    buf[n] = '';
    return n;
}

size_t log_fmt_raw_capture(char *buf, size_t cap, const log_raw_t *r)
{
    if (buf == NULL || cap == 0U || r == NULL) return 0U;
    if (r->tail_len > LOG_RAW_TAIL_MAX || (r->tail_len != 0U && r->tail == NULL)) return 0U;

    char head[40];
    int h = snprintf(head, sizeof(head), "RAW CH%u/UART%d last=%uB ", (unsigned)r->ch, r->uart,
                     (unsigned)r->tail_len);
    if (h <= 0 || (size_t)h >= sizeof(head) || (size_t)h >= cap) return 0U;
    memcpy(buf, head, (size_t)h);

    size_t n = (size_t)h;
    if (r->tail_len == 0U) {
        int w = snprintf(buf + n, cap - n, "hex=none");
        if (w < 0 || (size_t)w >= cap - n) return 0U;
        n += (size_t)w;
    } else {
        size_t w = hex_ascii(buf + n, cap - n, r->tail, r->tail_len);
        if (w == 0U) return 0U;
        n += w;
    }

    int t;
    if (r->have_pad_lamp) {
        t = snprintf(buf + n, cap - n, " pad=0x%02X lamp=0x%02X elf=%lu", r->pad, r->lamp,
                     (unsigned long)r->embedded_lf);
    } else {
        t = snprintf(buf + n, cap - n, " pad=n/a lamp=n/a elf=%lu", (unsigned long)r->embedded_lf);
    }
    return finish(t, cap - n) == 0U ? 0U : n + (size_t)t;
}

size_t log_fmt_raw_ol(char *buf, size_t cap, uint8_t ch, int uart,
                      const uint8_t *frame, size_t len)
{
    if (buf == NULL || cap == 0U || frame == NULL || len == 0U || len > LOG_RAW_TAIL_MAX) return 0U;
    char head[56];
    int h = snprintf(head, sizeof(head), "RAW CH%u/UART%d first-OL-frame=%uB ", (unsigned)ch, uart,
                     (unsigned)len);
    if (h <= 0 || (size_t)h >= sizeof(head) || (size_t)h >= cap) return 0U;
    memcpy(buf, head, (size_t)h);
    size_t w = hex_ascii(buf + h, cap - (size_t)h, frame, len);
    return w == 0U ? 0U : (size_t)h + w;
}

size_t log_fmt_link_transition(char *buf, size_t cap, const log_link_transition_t *t)
{
    if (buf == NULL || cap == 0U || t == NULL) return 0U;
    return finish(snprintf(buf, cap,
                           "CH%u/UART%d link %s -> %s reason=%s bytes=%lu valid=%lu "
                           "rejected=%lu sel=%s",
                           (unsigned)t->ch, t->uart, t->to_online ? "OFFLINE" : "ONLINE",
                           t->to_online ? "ONLINE" : "OFFLINE",
                           t->reason != NULL ? t->reason : "n/a",
                           (unsigned long)t->bytes, (unsigned long)t->valid,
                           (unsigned long)t->rejected, t->selected ? "Y" : "N"), cap);
}

void log_util_apply_levels(void)
{
    esp_log_level_set("*", ESP_LOG_INFO);
#if LOG_UTIL_SCALE_TRACE
    esp_log_level_set("RS485", ESP_LOG_DEBUG);
#endif
#if LOG_UTIL_MQTT_TRACE
    esp_log_level_set("MQTT", ESP_LOG_DEBUG);
#endif
}
